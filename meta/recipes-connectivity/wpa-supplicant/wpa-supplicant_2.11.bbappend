SYSTEMD_AUTO_ENABLE:wpa-supplicant = "enable"
SYSTEMD_SERVICE:wpa-supplicant = "wpa_supplicant.service"
